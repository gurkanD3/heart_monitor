## boards/designedbygurkan/custom_discovery/board.yml
```yaml
board:
  name: custom_discovery
  vendor: designedbygurkan
  socs:
    - name: nrf52833
```
